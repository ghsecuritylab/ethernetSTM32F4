# Keil uVision project ethernetSTM32F4.uvprojx, settings and files
target ethernetSTM32F4 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: ethernetSTM32F4
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Middlewares/Third_Party/LwIP/src/include;../Middlewares/Third_Party/LwIP/system;../Middlewares/Third_Party/LwIP/src/include/lwip;../Middlewares/Third_Party/LwIP/src/include/lwip/apps;../Middlewares/Third_Party/LwIP/src/include/lwip/priv;../Middlewares/Third_Party/LwIP/src/include/netif;../Middlewares/Third_Party/LwIP/src/include/netif/ppp;../Middlewares/Third_Party/LwIP/src/include/netif/ppp/polarssl;../Middlewares/Third_Party/LwIP/src/include/posix;../Middlewares/Third_Party/LwIP/src/include/posix/sys;../Middlewares/Third_Party/LwIP/system/arch;..\Drivers\Ethernet\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Drivers/CMSIS
    ../Drivers/CMSIS//Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_tim.c stm32f4xx_hal_flash.c stm32f4xx_hal_eth.c stm32f4xx_hal_usart.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c
  group Application/User
    ../Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c ethernetif.c lwip.c stm32f4_discovery.c
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/core/: inet_chksum.c dns.c memp.c raw.c sys.c netif.c stats.c pbuf.c tcp_in.c udp.c init.c lwip_timers.c def.c tcp.c tcp_out.c mem.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: ip6_frag.c ip6_addr.c ethip6.c ip6.c icmp6.c dhcp6.c nd6.c inet6.c mld6.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: ppp.c multilink.c pppol2tp.c eui64.c pppos.c pppoe.c upap.c demand.c fsm.c ecp.c eap.c utils.c chap_ms.c auth.c chap-new.c chap-md5.c ccp.c pppcrypt.c magic.c ipv6cp.c ipcp.c mppe.c vj.c lcp.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: igmp.c dhcp.c icmp.c ip4.c ip_frag.c autoip.c ip4_addr.c
    ../Middlewares/Third_Party/LwIP/src/api/: api_lib.c netifapi.c pppapi.c netbuf.c netdb.c api_msg.c sockets.c tcpip.c err.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/polarssl/: md5.c md4.c des.c arc4.c sha1.c
    ../Middlewares/Third_Party/LwIP/src/netif/: slipif.c etharp.c
  group Drivers/Ethernet
    ../Drivers/Ethernet/Src/: fs.c httpd.c httpd_cgi_ssi.c netconf.c stm32f4x7_eth_bsp.c
software components: CMSIS:CORE 4.1.0
